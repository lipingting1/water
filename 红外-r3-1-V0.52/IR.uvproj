# Keil uVision project IR.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IR +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user\LCD;.\user\I2C;.\user\parament;.\user\mel;.\user\file_sys;.\user\DSPs;.\user\UART
  group MAIN
    ./user/: main.c
  group measure
    ./user/mel/: MeaPro.c
  group parament
    ./user/parament/: SetPara.c
  group history
    ./user/file_sys/: HisRecord.c
  group uart
    ./user/UART/: Uart.c
  group RTC
    ./user/I2C/: I2C.C
  group DSPs
    ./user/DSPs/: DSPs.c
  group lcd
    ./user/LCD/: lcd.c
